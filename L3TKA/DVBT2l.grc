options:
  parameters:
    generate_options: qt_gui
    id: tjbritjb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 9.14286e6
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\etent\Downloads\adv4k64qam.ts
    length: '38'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 500e6
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '2432'
    input_size: '16384'
    tagname: ''
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    inband: INBAND_OFF
    mode: INPUTMODE_HIEFF
    rate1: C1_2
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C1_2
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C1_2
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C1_2
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvbt2_cellinterleaver_cc_0
  id: dtv_dvbt2_cellinterleaver_cc
  parameters:
    constellation: MOD_64QAM
    fecblocks: '139'
    framesize: FECFRAME_NORMAL
    tiblocks: '3'
  states: {}
- name: dtv_dvbt2_framemapper_cc_0
  id: dtv_dvbt2_framemapper_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    constellation: MOD_64QAM
    fecblocks: '139'
    fftsize1: FFTSIZE_16K
    framesize: FECFRAME_NORMAL
    guardinterval: GI_19_128
    l1constellation: L1_MOD_BPSK
    numdatasyms: '118'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_SISO
    rate: C1_2
    rotation: ROTATION_OFF
    t2frames: '2'
    tiblocks: '3'
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_freqinterleaver_cc_0
  id: dtv_dvbt2_freqinterleaver_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_16K
    guardinterval: GI_19_128
    numdatasyms: '118'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_SISO
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_interleaver_bb_0
  id: dtv_dvbt2_interleaver_bb
  parameters:
    constellation: MOD_64QAM
    framesize: FECFRAME_NORMAL
    rate: C1_2
  states: {}
- name: dtv_dvbt2_modulator_bc_0
  id: dtv_dvbt2_modulator_bc
  parameters:
    constellation: MOD_64QAM
    framesize: FECFRAME_NORMAL
    rotation: ROTATION_OFF
  states: {}
- name: dtv_dvbt2_p1insertion_cc_0
  id: dtv_dvbt2_p1insertion_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_16K
    guardinterval: GI_19_128
    numdatasyms: '118'
    preamble1: PREAMBLE_T2_SISO
    showlevels: SHOWLEVELS_OFF
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_pilotgenerator_cc_0
  id: dtv_dvbt2_pilotgenerator_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    equalization: EQUALIZATION_OFF
    fftsize: FFTSIZE_16K
    guardinterval: GI_19_128
    numdatasyms: '118'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_SISO
    version: VERSION_111
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: driver=rtlsdr,rtl=0
    bb_gain0: '20'
    bw0: 8e6
    freq0: 506e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    bandwidth0: 10e6
    center_freq0: 506e6
    dev_args: driver=rtlsdr,rtl=0
    driver: rtlsdr
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', soapy_custom_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', dtv_dvbt2_p1insertion_cc_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbt2_interleaver_bb_0, '0']
- [dtv_dvbt2_cellinterleaver_cc_0, '0', dtv_dvbt2_framemapper_cc_0, '0']
- [dtv_dvbt2_framemapper_cc_0, '0', dtv_dvbt2_freqinterleaver_cc_0, '0']
- [dtv_dvbt2_freqinterleaver_cc_0, '0', dtv_dvbt2_pilotgenerator_cc_0, '0']
- [dtv_dvbt2_interleaver_bb_0, '0', dtv_dvbt2_modulator_bc_0, '0']
- [dtv_dvbt2_modulator_bc_0, '0', dtv_dvbt2_cellinterleaver_cc_0, '0']
- [dtv_dvbt2_p1insertion_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [dtv_dvbt2_p1insertion_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [dtv_dvbt2_pilotgenerator_cc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
